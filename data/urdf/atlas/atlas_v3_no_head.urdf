Commit message: Recolor the Atlas

File: data/urdf/atlas/atlas_v3_no_head.urdf (robot description, URDF)
Before this commit: robot drc_skeleton, 34 links, 33 joints
Links:
- link utorso: geometry collision mesh filename=utorso.stl scale=1 1 1; collision mesh filename=utorso_pack.stl scale=1 1 1
